# Keil uVision project geek.uvprojx, settings and files
target Simulation (6220000::V6.22::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: geek
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\User;..\freertos;..\freertos\Source\include;..\freertos\Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM3\ARMCM3_ac6.sct
  group user
    ../User/: main.c
  group doc
    ../Doc/: ReadMe.txt
software components: CMSIS:CORE 6.1.0, Device:Startup 2.2.0
